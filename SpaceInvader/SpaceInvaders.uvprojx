# Keil uVision project SpaceInvaders.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Main.c SpaceInvader.h SpaceInvader.c Nokia5110.c Nokia5110.h sprites.h Test.h Test.c ADC0.h ADC0.c GPTM.c I2C0.c I2C.h MCP4725.h MCP4725.c GPTM1.h GPTM1.c Sounds.h button.h button.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
